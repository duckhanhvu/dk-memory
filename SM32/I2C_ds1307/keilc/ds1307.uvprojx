# Keil uVision project ds1307.uvprojx, settings and files
target ds1307 (ARM-ADS)
  device: STM32F030R8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: ds1307 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F0XX
  c include: ..\CMSIS\Device\ST\STM32F0xx\Include;..\keilc;..\STM32F0xx_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group LIB
    ../CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
    ../CMSIS/Device/ST/STM32F0xx/Include/: stm32f0xx.h system_stm32f0xx.h
    ./: stm32f0xx_conf.h stm32f0xx_it.h lcd_lib.h
    ../STM32F0xx_StdPeriph_Driver/inc/: stm32f0xx_i2c.h stm32f0xx_tim.h
  group User
    ./: main.c stm32f0xx_it.c
  group Std_peripheral_driver
    ../STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_misc.c stm32f0xx_rcc.c stm32f0xx_tim.c
  group Startup
    ../CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f0xx_ld.s
software components: CMSIS:CORE 4.1.0
